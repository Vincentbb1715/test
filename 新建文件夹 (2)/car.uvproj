# Keil uVision project car.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: car +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\delay;..\新建文件夹 (2)
  group Source Group 1
    ./: CAR.c lcd.c
    ./delay/: delay.c
